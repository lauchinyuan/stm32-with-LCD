# Keil uVision project 项目.uvprojx, settings and files
target 固件库工程 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 暑假项目
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\User;..\libraries\STM32F4xx_StdPeriph_Driver\inc;..\libraries\CMSIS\Include;..\libraries\CMSIS\Device\ST\STM32F4xx\Include;..\User\LED;..\User\usart;..\User\INOUTPUT;..\User\IIC;..\User\Sensor\DHT12;..\User\Sensor\MAX6675;..\User\Sensor\TCS3472;..\User\SPI;..\User\fsmc;..\User\Deveice\ILI9341;..\User\w25q16;..\User\Deveice\TSC2046;..\User\tim;..\User\Sensor\hx1838;..\User\Sensor\MPU9250;..\User\host_soft;..\User\rtc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group START UP
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group USER
    ../User/: main.c stm32f4xx_it.c
    ../User/LED/: led.c
    ../User/rtc/: rtc.c
    ../User/usart/: usart.c
    ../User/INOUTPUT/: inoutput.c
    ../User/IIC/: iic.c
    ../User/Sensor/DHT12/: dht12.c
    ../User/Sensor/TCS3472/: tcs3472.c
    ../User/fsmc/: fsmc.c
    ../User/Sensor/MAX6675/: max6675.c
    ../User/Deveice/ILI9341/: ili9341.c
    ../User/w25q16/: w25q16.c
    ../User/Deveice/TSC2046/: tsc2046.c
    ../User/tim/: tim.c
    ../User/Sensor/hx1838/: hx1838.c
    ../User/Sensor/MPU9250/: mpu9250.c
    ../User/host_soft/: host.c
  group CMSIS
    ../libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../libraries/CMSIS/Include/: core_cm4.h
  group STM32F407_StdPeriph
    ../libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
